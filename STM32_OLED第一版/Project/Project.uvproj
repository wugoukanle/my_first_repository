# Keil uVision project Project.uvproj, settings and files
target Project (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  c flags: Optim=1
  c include: ..\App;..\Bsp;..\Libraries\CM3;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Project;..\Bsp\delay;..\Bsp\nvic;..\Bsp\usart;..\Bsp\lcd
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STM32F10x_StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_spi.c stm32f10x_flash.c stm32f10x_rtc.c stm32f10x_iwdg.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_adc.c
  group STM32F10x_CM3
    ../Libraries/CM3/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group APP
    ../App/: App.c
  group BSP
    ../Bsp/: Bsp.c Timer.c sw-key.c RTC_time.c Globle_Var.c Li_Power.c flash.c spi.c sys.c
    ../Bsp/delay/: delay.c
    ../Bsp/nvic/: nvic.c
    ../Bsp/usart/: usart.c
    ../Bsp/lcd/: oled.c
